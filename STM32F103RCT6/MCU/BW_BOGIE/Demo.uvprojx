# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Source;.\Source\include;.\Source\portable\RVDS\ARM_CM3;.\User\USART;.\User\GPIO;.\User\NVIC;.\User\RCC;.\User\TIM;.\User\Semantic_Parser;.\User\PWM;.\User\Modes;.\User\Mode_Management;.\User\Mode_Config;.\User\L298N;.\User\NumToASCII;.\User\HCSR04;.\User\ADC;.\User\DMA
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group User
    ./: main.c stm32f10x_it.h stm32f10x_it.c stm32f10x_conf.h
    ./User/USART/: wulfric_usart.h wulfric_usart.c
    ./User/GPIO/: wulfric_gpio.h wulfric_gpio.c
    ./User/NVIC/: wulfric_nvic.h wulfric_nvic.c
    ./User/RCC/: wulfric_rcc.h wulfric_rcc.c
    ./User/TIM/: wulfric_tim.h wulfric_tim.c
    ./User/Semantic_Parser/: semantic_parser.h semantic_parser.c
    ./User/PWM/: pwm.h pwm.c
    ./User/Modes/: free_mode.h free_mode.c avoidance_mode.h avoidance_mode.c tracking_mode.h tracking_mode.c
    ./User/Mode_Config/: mode_config.h mode_config.c
    ./User/Mode_Management/: mode_management.h mode_management.c
    ./User/L298N/: l298n.h l298n.c
    ./User/HCSR04/: hc_sr04.h hc_sr04.c
    ./User/NumToASCII/: num_to_ascii.h num_to_ascii.c
    ./User/ADC/: wulfric_adc.h wulfric_adc.c
    ./User/DMA/: wulfric_dma.h wulfric_dma.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h system_stm32f10x.c
  group StdPeriph
    ./Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_wwdg.h stm32f10x_usart.h stm32f10x_tim.h stm32f10x_spi.h stm32f10x_sdio.h stm32f10x_rtc.h stm32f10x_rcc.h stm32f10x_pwr.h stm32f10x_iwdg.h stm32f10x_i2c.h stm32f10x_gpio.h stm32f10x_fsmc.h stm32f10x_flash.h stm32f10x_exti.h stm32f10x_dma.h stm32f10x_dbgmcu.h stm32f10x_dac.h stm32f10x_crc.h stm32f10x_cec.h stm32f10x_can.h stm32f10x_bkp.h stm32f10x_adc.h
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_adc.c
  group FreeRTOS
    ./Source/include/: FreeRTOS.h task.h list.h queue.h
    ./Source/: tasks.c queue.c list.c
    ./Source/portable/MemMang/: heap_2.c
    ./Source/portable/RVDS/ARM_CM3/: portmacro.h port.c
